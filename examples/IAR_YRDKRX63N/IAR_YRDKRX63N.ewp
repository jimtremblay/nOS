# IAR project IAR_YRDKRX63N.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x0
  ICCRX.CCIncludePath2: $PROJ_DIR$; ..\..\source; ..\..\source\port\IAR\RX600
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\; $PROJ_DIR$
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  General.OGChipSelectMenu: RX600 Generic RX600
  General.StackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: NDEBUG
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  group (top)
    ./: main.c
  group nOS
    ../../source/: nOSEvent.c nOSFlag.c nOSList.c nOSMem.c nOSMutex.c nOSQueue.c nOSSched.c nOSSem.c nOSThread.c nOSTime.c nOSTimer.c
    ../../source/port/IAR/RX600/: nOSPort.c nOSPortASM.s
