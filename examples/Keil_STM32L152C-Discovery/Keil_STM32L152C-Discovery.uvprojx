# Keil uVision project Keil_STM32L152C-Discovery.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Keil_STM32L152C-Discovery
  c flags: Optim=1 uC99=1 wLevel=2
  c include: .\;..\..\include;..\..\include\port\Keil\ARM_Cortex_M3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
  group nOS
    ../../source/: nOSEvent.c nOSFlag.c nOSList.c nOSMem.c nOSMutex.c nOSQueue.c nOSSched.c nOSSem.c nOSThread.c nOSTime.c nOSTimer.c
    ../../source/port/Keil/ARM_Cortex_M3/: nOSPort.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
