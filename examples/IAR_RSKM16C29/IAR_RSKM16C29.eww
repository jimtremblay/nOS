<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAR_RSKM16C29.ewp</path>
  </project>
  <batchBuild/>
</workspace>


