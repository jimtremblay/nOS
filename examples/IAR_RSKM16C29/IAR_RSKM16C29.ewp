# IAR project IAR_RSKM16C29.ewp, settings and files
configuration Debug (M16C, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlm16cnnffwcn.h
  General.GData16HeapSize: 0
  General.GFarHeapSize: 0
  General.GData20HeapSize: 0
  General.GStackSize: 128
  General.GIStackSize: 64
  General.OGChipSelectMenu: M30290FC M30290FC
  ICCM16C.newCCIncludePaths: $PROJ_DIR$; ..\..\include; ..\..\include\port\IAR\M16C
  ICCM16C.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICCM16C.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm16c.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkInterruptStackSize: 1
configuration Release (M16C)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.GData16HeapSize: 1024
  General.GFarHeapSize: 1024
  General.GData20HeapSize: 1024
  General.GStackSize: 256
  General.OGChipSelectMenu: M16CGEN Generic M16C
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group nOS
    ../../source/: nOSEvent.c nOSFlag.c nOSList.c nOSMem.c nOSMutex.c nOSQueue.c nOSSched.c nOSSem.c nOSThread.c nOSTime.c nOSTimer.c
    ../../source/port/IAR/M16C/: nOSPort.c
