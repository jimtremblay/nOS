# Keil uVision project Keil_STM32F429I-Discovery.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Keil_STM32F429I-Discovery
  c flags: Optim=1 uC99=1 wLevel=2
  c include: .\;..\..\source;..\..\source\port\Keil\ARM_Cortex_M4
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./: main.c
  group nOS
    ../../source/: nOSEvent.c nOSFlag.c nOSList.c nOSMem.c nOSMutex.c nOSQueue.c nOSSched.c nOSSem.c nOSThread.c nOSTime.c nOSTimer.c
    ../../source/port/Keil/ARM_Cortex_M4/: nOSPort.c
software components: CMSIS:CORE 3.30.0, Device:Startup 2.1.0
