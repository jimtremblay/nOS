<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAR_STM32F429I-Discovery.ewp</path>
  </project>
  <batchBuild/>
</workspace>


