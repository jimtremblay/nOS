# IAR project IAR_STM32F429I-Discovery.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; ..\..\source; ..\..\source\port\IAR\ARM_Cortex_M4; CMSIS\Device\ST\STM32F4xx\Include; CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\linker\stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
    CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429xx.s
    CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group nOS
    ../../source/: flag.c mem.c mutex.c queue.c sched.c sem.c thread.c timer.c
    ../../source/port/IAR/ARM_Cortex_M4/: port.c portasm.s
