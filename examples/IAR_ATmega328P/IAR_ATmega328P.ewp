# IAR project IAR_ATmega328P.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m328p ATmega328P
  ICCAVR.newCCIncludePaths: $PROJ_DIR$; ..\..\source; ..\..\source\port\IAR\AVR
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: main.c
  group nOS
    ../../source/: nOSEvent.c nOSFlag.c nOSList.c nOSMem.c nOSMutex.c nOSQueue.c nOSSched.c nOSSem.c nOSThread.c nOSTime.c nOSTimer.c
    ../../source/port/IAR/AVR/: nOSPort.c
