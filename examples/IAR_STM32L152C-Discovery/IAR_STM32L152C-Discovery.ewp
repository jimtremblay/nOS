# IAR project IAR_STM32L152C-Discovery.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xC ST STM32L152xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\source; ..\..\source\port\IAR\ARM_Cortex_M3; CMSIS\Include; CMSIS\Device\ST\STM32L1xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_STM32L152C-Discovery.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
    CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_mdp.s
    CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group nOS
    ../../source/: nOSEvent.c nOSFlag.c nOSList.c nOSMem.c nOSMutex.c nOSQueue.c nOSSched.c nOSSem.c nOSThread.c nOSTime.c nOSTimer.c
    ../../source/port/IAR/ARM_Cortex_M3/: nOSPort.c nOSPortASM.s
