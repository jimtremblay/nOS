# IAR project IAR_FRDM-KL25Z.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\include; ..\..\include\port\IAR\ARM_Cortex_M0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_FRDM-KL25Z.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c startup_MKL25Z4.s system_MKL25Z4.c
  group nOS
    ../../source/: nOSEvent.c nOSFlag.c nOSList.c nOSMem.c nOSMutex.c nOSQueue.c nOSSched.c nOSSem.c nOSSignal.c nOSThread.c nOSTime.c nOSTimer.c
    ../../source/port/IAR/ARM_Cortex_M0/: nOSPort.c nOSPortASM.s
