# Keil uVision project Keil_FRDM-KL25Z.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x3000) IRAM2(0x1FFFF000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Keil_FRDM-KL25Z
  c flags: Optim=1 uC99=1 wLevel=2
  c include: .\;..\..\source;..\..\source\port\Keil\ARM_Cortex_M0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  group nOS
    ../../source/: nOSEvent.c nOSFlag.c nOSList.c nOSMem.c nOSMutex.c nOSQueue.c nOSSched.c nOSSem.c nOSThread.c nOSTime.c nOSTimer.c
    ../../source/port/Keil/ARM_Cortex_M0/: nOSPort.c
  group src
    ./: main.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
